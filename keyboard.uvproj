# Keil uVision project keyboard.uvproj, settings and files
target Target 1 (MCS-51)
  device: SH68F83 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) CLOCK(6000000)
  output: keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group main
    ./src/: keyboard.c MAIN.c
